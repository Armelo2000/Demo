# Keil uVision project RemoteControl.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RemoteControl +hex
  c flags: Optim=1
  c define: USE_HAL_DRIVER, STM32F103xB, HAL_UART_MODULE_ENABLED,STM32F10X_MD, HAL_TIM_MODULE_ENABLED, LCD16X2_LINES
  c include: .\Inc;.\Drivers\STM32F1xx_HAL_Driver\Inc;.\Drivers\CMSIS\Device\ST\STM32F1xx\Include;.\Drivers\CMSIS\Include;.\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;.\lcd_lib
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ./: startup_stm32f103xb.s
  group Drivers/CMSIS
    ./Drivers/CMSIS/: system_stm32f10x.c
  group User
    ./Src/: stm32f1xx_hal_msp.c stm32f1xx_it.c delay.c main.c
  group HAL
    ./Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_exti.c
  group LCD
    ./Src/: i2c_lcd.c lcd.c
  group led
    ./Src/: led.c
target Simulator (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RemoteControl
  c flags: Optim=1
  c define: USE_HAL_DRIVER, STM32F103xB, HAL_UART_MODULE_ENABLED,STM32F10X_MD
  c include: .\Inc;.\Drivers\STM32F1xx_HAL_Driver\Inc;.\Drivers\CMSIS\Device\ST\STM32F1xx\Include;.\Drivers\CMSIS\Include;.\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
